Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Plank\EBC-PLNK-2815-000 PLANK.IFC
Time: 2025-01-06T11:09:02+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 7.8808799999999781; Volume Measure: 0.0078808800000000; Area Measure: 1.6138268707307319

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 7.8808799999999781; Volume Measure: 0.0078808800000000; Area Measure: 1.6138268707307319

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 7.8808799999999781; Volume Measure: 0.0078808800000000; Area Measure: 1.6138268707307319

# IfcBuildingElementProxy (2)
In: default BuildingStorey
Name
EBC-PLNK-2815-000 PLANK | PSet_Mass_Property - Mass Measure: 7.8808799999999781; Volume Measure: 0.0078808800000000; Area Measure: 1.6138268707307319
EBC-PLNK-2815-000 PLANK
