Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Plank\EBC-PLNK-2825-000 PLANK.IFC
Time: 2025-01-06T11:08:21+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 11.4688799999999542; Volume Measure: 0.0114688800000000; Area Measure: 2.2342150958301219

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 11.4688799999999542; Volume Measure: 0.0114688800000000; Area Measure: 2.2342150958301219

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 11.4688799999999542; Volume Measure: 0.0114688800000000; Area Measure: 2.2342150958301219

# IfcBuildingElementProxy (2)
In: default BuildingStorey
Name
EBC-PLNK-2825-000 PLANK | PSet_Mass_Property - Mass Measure: 11.4688799999999542; Volume Measure: 0.0114688800000000; Area Measure: 2.2342150958301219
EBC-PLNK-2825-000 PLANK
