Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Plank\EBC-PLNK-2825-000 PLANK FULL ASSEMBLY.IFC
Time: 2025-01-06T11:05:51+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 11.5252313471246506; Volume Measure: 0.0115252313471247; Area Measure: 2.2953767611295222

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 11.5252313471246506; Volume Measure: 0.0115252313471247; Area Measure: 2.2953767611295222

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 11.5252313471246506; Volume Measure: 0.0115252313471247; Area Measure: 2.2953767611295222

# IfcBuildingElementProxy (23)
In: default BuildingStorey
Name
EBC-PLNK-2825-000 PLANK FULL ASSEMBLY | PSet_Mass_Property - Mass Measure: 11.5252313471246506; Volume Measure: 0.0115252313471247; Area Measure: 2.2953767611295222
H Section Hanging Extrusion + F000264 P50 Suspension Fitting
3 x H Section Hanging Extrusion - 100mm
3 x F000264 P50 SUSPENSION FITTING.SLDPRT
3 x F000264 P50 Top Threaded Insert
3 x F000264 P50 Tensile Steel Wire 2m
3 x F000264 P50 Clutch Fitting
3 x F000264 P50 M5 Threaded Bolt
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-1
H Section Hanging Extrusion + F000264 P50 Suspension Fitting-2
EBC-PLNK-2825-000 PLANK
