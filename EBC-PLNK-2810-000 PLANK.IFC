Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Plank\EBC-PLNK-2810-000 PLANK.IFC
Time: 2025-01-06T11:09:54+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 6.0868800000000043; Volume Measure: 0.0060868800000000; Area Measure: 1.3036327581810367

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 6.0868800000000043; Volume Measure: 0.0060868800000000; Area Measure: 1.3036327581810367

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 6.0868800000000043; Volume Measure: 0.0060868800000000; Area Measure: 1.3036327581810367

# IfcBuildingElementProxy (2)
In: default BuildingStorey
Name
EBC-PLNK-2810-000 PLANK | PSet_Mass_Property - Mass Measure: 6.0868800000000043; Volume Measure: 0.0060868800000000; Area Measure: 1.3036327581810367
EBC-PLNK-2810-000 PLANK
